# IAR project Backup (2) of RM48_MU2E_CNTRL_V1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: RM48L952ZWT TexasInstruments RM48L952ZWT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 42
  General.FPU2: 3
  ICCARM.CCDefines: _TMS470_BIG
  ICCARM.CCIncludePath2: $PROJ_DIR$; include; source; nHetCap
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MU2E_CNTRL_V1.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: C:\TI_PROJECTS\RM48_MU2E_CNTRL_V1\RM48L952.icf
  ILINK.IlinkProgramEntryLabel: _c_int00
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group HET
    nHetCap/: nHetCap.c nHetCap.h
  group INC
    include/: adc.h can.h crc.h dcc.h Device_header.h Device_RM48.h Device_types.h dmm.h emac.h emif.h esm.h fee_interface.h gio.h hal_stdtypes.h het.h htu.h hw_emac.h hw_emac_ctrl.h hw_mdio.h hw_reg_access.h hw_usb.h i2c.h lin.h mdio.h MemMap.h mibspi.h nHetCap.h phy_dp83640.h pinmux.h pom.h reg_adc.h reg_can.h reg_crc.h reg_dcc.h reg_dma.h reg_dmm.h reg_efc.h reg_emif.h reg_esm.h reg_flash.h reg_gio.h reg_het.h reg_htu.h reg_i2c.h reg_lin.h reg_mibspi.h reg_pbist.h reg_pcr.h reg_pinmux.h reg_pmm.h reg_pom.h reg_rti.h reg_rtp.h reg_sci.h reg_spi.h reg_stc.h reg_system.h reg_tcram.h reg_vim.h rti.h rtp.h sci.h spi.h std_nhet.h sys_common.h sys_core.h sys_dma.h sys_mpu.h sys_pcr.h sys_pmm.h sys_pmu.h sys_selftest.h sys_vim.h system.h ti_fee.h ti_fee_cfg.h ti_fee_types.h usb-ids.h usb.h usb_serial_structs.h usbcdc.h usbdcdc.h usbdevice.h usbdevicepriv.h usblib.h
  group MU2E CONTROLLER
    source/: fram.c Mu2e_Ctrl.c Mu2e_Ctrl_DAQ_LVDS.c Mu2e_Ctrl_DAQ_PHY.c Mu2e_Ctrl_i2c.c Mu2e_Ctrl_Misc.c sys_main.c ver_ePHY.h ver_help.h ver_io.h
  group OrangeTree ZestETM1
    source/: ZestETM1_SOCKET.h ZestETM1_SPI.c ZestSock-TEK.c
  group SRC
    source/: adc.c crc.c dabort.asm emif.c esm.c gio.c het.c i2c.c notification.c pinmux.c rti.c sci.c spi.c sys_core.asm sys_dma.c sys_intvecs.asm sys_mpu.asm sys_pcr.c sys_phantom.c sys_pmm.c sys_pmu.asm sys_selftest.c sys_startup.c sys_vim.c system.c
